# Keil uVision project libpixy_m0.uvproj, settings and files
target libpixy_m0 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: libpixy_m0 (library)
  c flags: Optim=1 OneElfS=1
  c define: CORE_M0  IPC_SLAVE PIXY
  c include: ., ..\..\common
  asm define: NO_CRP  IPC_SLAVE
  library: MicroLIB
  group Source Code
    ./: debug_frmwrk.c ipc_mbx.c lpc43xx_uart.c debug.c chirp.c smlink.c
